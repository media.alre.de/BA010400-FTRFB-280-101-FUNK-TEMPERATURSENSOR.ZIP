Properties of the parts of a building model (IFC2X3)

# File
Description: Funk-Raumtemperatursensor, Aufputz superflach, ohne Sollwertsteller, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: BA010400, Funk-Raumtemperatursensor, Aufputz superflach, ohne Sollwertsteller
In: Raum
Description: Funk-Sensoren für in Wohn-, Büro- und Hotelräumen üblichen Verschmutzungsgrad. Anwendung überwiegend im Sanierungsbereich oder bei Heizungsanlagenerweiterungen. Funk-Raumtemperatursensor zur Erfassung der Raumtemperatur. In Verwendung mit alre-Funk-Aktoren wird eine Einzelraum-Temperaturregelung, Mittelwertbildung oder Zentralregelung verwirklicht. Ein in Kürze notwendiger Batteriewechsel wird am Sensor signalisiert.; Classification: EC001101 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: BA010400; ModelLabel: FTRFB-280.101; GlobalTradeItemNumber: 4050528014955; ProductURL: https://alre.de/produkt_BA010400
Pset_Specification - NominalLength: 0.0785 m; NominalWidth: 0.078 m; NominalDepth: 0.0139 m; NetWeight: 0.072
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Zusammenstellung: Basiselement mit Komplettgehäuse; Farbe: weiß; Oberflächenschutz: unbehandelt; Mit Display: no; Werkstoffgüte: Thermoplast; Bussystem Funkbus: yes; Mit Busankopplung: yes; Werkstoff: Kunststoff; Mit Diebstahl-/Demontageschutz: no; Parallel-Betrieb möglich: yes; RAL-Nummer (ähnlich): 9010; Schutzart (IP): IP30; Mit LED-Anzeige: yes; Ausführung der Oberfläche: glänzend; Mit Vor-Ort Bedienung: no; Funk bidirektional: no; Bussystem KNX Secure: no; Bussystem KNX Secure-RF (Funk): no; ETIM-Klasse: EC001101; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-BA010400.pdf
